# Keil uVision project Mini5D_fly.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Mini52LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x1FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Mini5D_fly
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group LIB
    ./Source/: startup_MINI51.s Mini5D_BLDC_V16.c
  group App
    ./Source/: Mini5D_fly.c mini5D_BLDC_main.c
