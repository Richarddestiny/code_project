/******************************************************************************

                  版权所有 (C), 2016-2026, 深圳进化动力数码科技有限公司

 ******************************************************************************
  文 件 名   : dbg.h
  版 本 号   : 初稿
  作    者   : 彭斌全
  生成日期   : 2016年4月15日
  最近修改   :
  功能描述   : dbg.c 的头文件
  函数列表   :
  修改历史   :
  1.日    期   : 2016年4月15日
    作    者   : 彭斌全
    修改内容   : 创建文件

******************************************************************************/

#ifndef __DBG_H__
#define __DBG_H__

/*----------------------------------------------*
 * 包含头文件                                   *
 *----------------------------------------------*/
#include <syslog.h>
#include <sys/statfs.h>
#include "main.h"
#include "app.h"

#ifdef __cplusplus
#if __cplusplus
extern "C"{
#endif
#endif /* __cplusplus */

/*----------------------------------------------*
 * 外部变量说明                                 *
 *----------------------------------------------*/
extern u8 g_hdmi_debug_switch;
extern u8 g_app_preview_debug_switch;
extern u8 g_init_debug_switch;

/*----------------------------------------------*
 * 外部函数原型说明                             *
 *----------------------------------------------*/

/*----------------------------------------------*
 * 内部函数原型说明                             *
 *----------------------------------------------*/

/*----------------------------------------------*
 * 全局变量                                     *
 *----------------------------------------------*/
extern u8 g_debug_switch;

/*----------------------------------------------*
 * 模块级变量                                   *
 *----------------------------------------------*/

/*----------------------------------------------*
 * 常量定义                                     *
 *----------------------------------------------*/

/*----------------------------------------------*
 * 宏定义                                       *
 *----------------------------------------------*/
#define DEBUG_OFF   0
#define DEBUG_ON    1

/*----------------------------------------------*
 * 宏函数定义                                   *
 *----------------------------------------------*/

/* 如果打开调试开关，记录DEBUG级别系统日志，同时输出内容 */
#define dbg(fmt, arg...) \
        do { \
                if (DEBUG_ON == g_debug_switch) { \
                        syslog(LOG_DEBUG, "[dock] "fmt, ##arg);\
                        printf("[dock] "fmt, ##arg);\
                }\
        } while (0)

/*  记录INFO级别系统日志，同时输出内容 */
#define msg(fmt, arg...) \
        do { \
                syslog(LOG_INFO, "[dock] "fmt, ##arg);\
                printf("[dock] "fmt, ##arg);\
        } while (0)

/*----------------------------------------------*
 * 对外函数原型说明                             *
 *----------------------------------------------*/

/*****************************************************************************
 函 数 名  : set_system_log
 功能描述  : 设置系统日志
*****************************************************************************/
extern void set_system_log(void);

/*****************************************************************************
 函 数 名  : dbg_console
 功能描述  : 调试控制台实现函数
*****************************************************************************/
extern void dbg_console(void);

#ifdef __cplusplus
#if __cplusplus
}
#endif
#endif /* __cplusplus */


#endif /* __DBG_H__ */

